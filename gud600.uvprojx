# Keil uVision project gud600.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32F103RE GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gud600 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: .\Start;.\User;.\Library;.\fs;.\MALLOC;.\sfud\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\gud600.sct
  group User
    ./User/: gd32f10x_it.c gd32f10x_it.h gd32f10x_libopt.h main.h systick.c systick.h main.c usart.c usart.h gpio.c gpio.h adc.c adc.h spi_flash.c spi_flash.h lcd.c can.c can.h i2c.c rtc.c misc.c misc.h bsp_timer.c bw236.c bw236.h
  group Library
    ./Library/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Start
    ./Start/: system_gd32f10x.c startup_gd32f10x_md.s startup_gd32f10x_hd.s
  group fs
    ./fs/: lfs_util.c lfs_port.c lfs.c
  group MALLOC
    ./MALLOC/: malloc.c
  group sfud
    ./sfud/port/: sfud_port.c
    ./sfud/src/: sfud.c sfud_sfdp.c
